# IAR project boot.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: boot.s19
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: E:\zhang\我的项目\RT5512,  RT5510 STM8 BOOTLOAD  (2018-12-15)V2.03\STM8boot(XMODE)\lnkstm8s105c4.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_gpio.c
  group user
    ./: include.h main.c
    driver/: led.c uart.c xmodem.c
  group user/src
    driver/: crc.c
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_flash.c stm8s_uart2.c stm8s_wwdg.c
