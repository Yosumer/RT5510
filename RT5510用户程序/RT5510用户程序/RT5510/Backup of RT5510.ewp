# IAR project Backup of RT5510.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; lib\src; lib\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: RT5510_Main_RT000_V2.01_20181214.s19
  ILINK.IlinkOutputFile: RT5510.out
  ILINK.IlinkIcfFile: E:\zhang\我的项目\RT5512,  RT5510 STM8 BOOTLOAD  (2018-12-14 有方网络板)V2.01\RT5512用户程序\lnkstm8s105c4.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group lib
    lib/inc/: stm8s.h
    lib/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c
  group source
    ./: comm.h Data_Cul.c Input.c KneadMotor.c main.c stm8s_conf.h stm8s_it.c time4.c Timer.c uart485.c uart485.h WalkMotor.c
